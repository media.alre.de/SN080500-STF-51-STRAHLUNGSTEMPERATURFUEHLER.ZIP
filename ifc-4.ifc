Properties of the parts of a building model (IFC4)

# File
Description: Strahlungstemperaturfühler, 2x KTY 81-121, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: SN080500, Strahlungstemperaturfühler, 2x KTY 81-121
In: Raum
Description: Doppelfühler zur Erfassung von Strahlungs- und Raumwärme. Ein Fühler befindet sich in der schwarzen Halbkugel als Strahlungsfühler, der andere Fühler im Kunststoffgehäuse als Raumfühler.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: SN080500; ModelLabel: STF-51; GlobalTradeItemNumber: 4050528055699; ProductURL: https://alre.de/produkt_SN080500
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.077
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Geeignet für Wandmontage: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: -20; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP30; Einsatzgebiet: Raum; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensortyp: sonstige; Gehäusehöhe: 83.4; Gehäusebreite: 78.3; Gehäusetiefe: 25.5; Festes Kabel am Sensor: no; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-SN080500.pdf
